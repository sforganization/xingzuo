# IAR project Lets.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ../STM8S_StdPeriph_Driver/inc; ../App/; ../App/KeyApp/; ../App/MainTaskApp/; ../App/EEROM/; ../App/WirlessApp/; ../App/PowerApp/
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8s_WYLedV1.00R1_20130714.hex
  ILINK.IlinkOutputFile: LED_RGB.out
  ILINK.IlinkIcfFile: E:\work\Project\LED_WY_WireLess\stm8s_WYLedV1.00R0_20130714\Project\lnkstm8s003f3.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  ICCSTM8.CCDefines: NDEBUG
configuration Lamp (STM8, debug)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 1
  General.GenStackSize: 0x200
  ICCSTM8.CCDefines: STM8S105; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: ../STM8S_StdPeriph_Driver/inc; ../App/; ../App/MainTaskApp/; ../App/Uart/
  OBJCOPY.OOCOutputFile: 星座2018.hex
  ILINK.IlinkIcfFile: lnkstm8s105k6.icf
  group App
    ../App/: LED_driver.c main.c stm8s_conf.h stm8s_it.c stm8s_user.c
  group App/MainTaskApp
    ../App/MainTaskApp/: MainTaskApp.c
  group App/UART
    ../App/Uart/: uart.c uart.h
  group STM8S_StdPeriph_Driver/INC
    ../STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_tim1.h
  group STM8S_StdPeriph_Driver/SRC
    ../STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_uart2.c
